# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MyCode\led;..\MyCode\Motor;..\MyCode\encoder;..\MyCode\iic;..\MyCode\DMP;..\MyCode\EXTI;..\MyCode\mpu6050;..\MyCode\control;..\MyCode\DataScope_DP;..\MyCode\filter
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MyCode
    ../MyCode/led/: LED.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../MyCode/Motor/: moto.c
    ../MyCode/encoder/: encoder.c
    ../MyCode/iic/: IOI2C.c
    ../MyCode/mpu6050/: MPU6050.c
    ../MyCode/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MyCode/EXTI/: exti.c
    ../MyCode/control/: control.c
    ../MyCode/DataScope_DP/: DataScope_DP.C
    ../MyCode/filter/: filter.c
